# Keil uVision project Template.uvproj, settings and files
target Normal (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drivers;..\..\modules;.\app
  group App
    ./app/: main.c
  group Drivers
    ./: board.c
    ./drivers/: drv_uart.c
